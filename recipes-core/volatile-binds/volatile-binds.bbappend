VOLATILE_BINDS:append = "\
    /var/volatile/home /home\n\
"