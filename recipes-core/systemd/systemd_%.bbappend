FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Added-Rule-for-fb0-to-systemd.rules.patch"

